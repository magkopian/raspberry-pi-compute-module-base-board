# Repository magkopian/raspberry-pi-compute-module-base-board

File README.md:

Raspberry Pi Compute Module Base Board
================================

## Description:

These are the design files for a circuit board intended to be used as a base for other custom PCB designs that make use of the Raspberry Pi Compute Module.

If you want to design a custom PCB based on the Raspberry Pi Compute Module but you have never done it before, this project can serve as a starting point. The board is designed on KiCAD which is an open source and cross-platform EDA software, in order to allow as many people as possible to take advantage of it.

More information about the project can be found on [Instructables](https://www.instructables.com/id/Design-Your-Own-Raspberry-Pi-Compute-Module-PCB/).

## License:

Raspberry Pi Compute Module Base Board

Copyright (C) 2018  Manolis Agkopian

This program is free software: you can redistribute it and/or modify it under the terms of the GNU General Public License as published by the Free Software Foundation, either version 3 of the License, or (at your option) any later version.

This program is distributed in the hope that it will be useful, but WITHOUT ANY WARRANTY; without even the implied warranty of MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE. See the GNU General Public License for more details.

You should have received a copy of the GNU General Public License along with this program. If not, see https://www.gnu.org/licenses/.

### Third party schematic symbols and footprints:

This project makes use of the CM schematic symbols and DDR2 SODIMM fooprint designed by [Joan The Spark](https://github.com/JoanTheSpark/KiCAD) and distrubuted under the [GNU General Public License Version 3](https://www.gnu.org/licenses/gpl.html).

It also makes use of the HDMI connector schematic symbol from the [Digikey KiCAD Library](https://github.com/digikey/digikey-kicad-library) repository which is distrubuted under the [Creative Commons CC-BY-SA 4.0](https://creativecommons.org/licenses/by-sa/4.0).

## KiCad design compute_module.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C12, C13, C18, C19: 100nF; C_0402
D1: GREEN LED; LED_0805
D8: RED LED; LED_0805
MD1: Board_RPi_CM3_200pConnector_multipart; Conn_TE-DDR2-SODIMM-0.6-200P-doublesided
Q1: 2N7002P.215; SOT-23
R1, R7, R8: 100K; R_0603_HandSoldering
R2, R3, R11: 1K; R_0603_HandSoldering
R9, R10, R16, R17: 1.8K; R_0603_HandSoldering

Connections:
+1V8: C1.1, C2.1, MD1.183 (1V8), MD1.184 (1V8), MD1.185 (1V8), MD1.186 (1V8), R1.1; also elsewhere on the board
+3V3: C3.1, C4.1, C5.1, C6.1, C12.1, C13.1, C18.1, C19.1, MD1.39 (GPIO0-27_VDD), MD1.40 (GPIO0-27_VDD), MD1.41 (GPIO28-45_VDD), MD1.42 (GPIO28-45_VDD), MD1.189 (VDAC), MD1.190 (VDAC), MD1.191 (3V3), MD1.192 (3V3), MD1.193 (3V3), MD1.194 (3V3), R2.1, R9.1, R10.1, R11.1, R16.1, R17.1; also elsewhere on the board
+5V: C7.1, C8.1, MD1.197 (VBAT), MD1.198 (VBAT), MD1.199 (VBAT), MD1.200 (VBAT); also elsewhere on the board
CAM0_C_N: MD1.144 (CAM0_CN); also elsewhere on the board
CAM0_C_P: MD1.142 (CAM0_CP); also elsewhere on the board
CAM0_D0_N: MD1.138 (CAM0_DN0); also elsewhere on the board
CAM0_D0_P: MD1.136 (CAM0_DP0); also elsewhere on the board
CAM0_D1_N: MD1.150 (CAM0_DN1); also elsewhere on the board
CAM0_D1_P: MD1.148 (CAM0_DP1); also elsewhere on the board
CAM0_IO0: MD1.36 (GPIO31); also elsewhere on the board
CAM0_IO1: MD1.34 (GPIO30); also elsewhere on the board
CAM1_C_N: MD1.149 (CAM1_CN); also elsewhere on the board
CAM1_C_P: MD1.147 (CAM1_CP); also elsewhere on the board
CAM1_D0_N: MD1.161 (CAM1_DN0); also elsewhere on the board
CAM1_D0_P: MD1.159 (CAM1_DP0); also elsewhere on the board
CAM1_D1_N: MD1.155 (CAM1_DN1); also elsewhere on the board
CAM1_D1_P: MD1.153 (CAM1_DP1); also elsewhere on the board
CAM1_D2_N: MD1.143 (CAM1_DN2); also elsewhere on the board
CAM1_D2_P: MD1.141 (CAM1_DP2); also elsewhere on the board
CAM1_D3_N: MD1.137 (CAM1_DN3); also elsewhere on the board
CAM1_D3_P: MD1.135 (CAM1_DP3); also elsewhere on the board
CAM1_IO0: MD1.11 (GPIO3); also elsewhere on the board
CAM1_IO1: MD1.9 (GPIO2); also elsewhere on the board
CD0_SCL: MD1.30 (GPIO29), R10.2; also elsewhere on the board
CD0_SDA: MD1.28 (GPIO28), R9.2; also elsewhere on the board
CD1_SCL: MD1.5 (GPIO1), R17.2; also elsewhere on the board
CD1_SDA: MD1.3 (GPIO0), R16.2; also elsewhere on the board
EMMC_EN_N_1V8: MD1.90 (EMMC_EN_N_1V8), Q1.1 (G), R1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C12.2, C13.2, C18.2, C19.2, D8.1 (K), MD1.1 (GND), MD1.7 (GND), MD1.8 (GND), MD1.13 (GND), MD1.14 (GND), MD1.19 (GND), MD1.20 (GND), MD1.25 (GND), MD1.26 (GND), MD1.31 (GND), MD1.32 (GND), MD1.37 (GND), MD1.38 (GND), MD1.43 (GND), MD1.44 (GND), MD1.49 (GND), MD1.50 (GND), MD1.55 (GND), MD1.56 (GND), MD1.61 (GND), MD1.62 (GND), MD1.67 (GND), MD1.68 (GND), MD1.73 (GND), MD1.74 (GND), MD1.79 (GND), MD1.80 (GND), MD1.85 (GND), MD1.86 (GND), MD1.91 (GND), MD1.92 (GND), MD1.97 (GND), MD1.98 (GND), MD1.103 (GND), MD1.104 (GND), MD1.109 (GND), MD1.110 (GND), MD1.115 (GND), MD1.116 (GND), MD1.121 (GND), MD1.122 (GND), MD1.127 (GND), MD1.133 (GND), MD1.134 (GND), MD1.139 (GND), MD1.140 (GND), MD1.145 (GND), MD1.146 (GND), MD1.151 (GND), MD1.152 (GND), MD1.157 (GND), MD1.163 (GND), MD1.164 (GND), MD1.169 (GND), MD1.170 (GND), MD1.181 (GND), MD1.182 (GND), MD1.187 (GND), MD1.188 (GND), MD1.195 (GND), MD1.196 (GND), Q1.2 (S), R3.2, R7.2, R8.2; also elsewhere on the board
GPIO4: MD1.15 (GPIO4); also elsewhere on the board
GPIO5: MD1.17 (GPIO5); also elsewhere on the board
GPIO6: MD1.21 (GPIO6); also elsewhere on the board
GPIO7: MD1.23 (GPIO7); also elsewhere on the board
GPIO8: MD1.27 (GPIO8); also elsewhere on the board
GPIO9: MD1.29 (GPIO9); also elsewhere on the board
GPIO10: MD1.33 (GPIO10); also elsewhere on the board
GPIO11: MD1.35 (GPIO11); also elsewhere on the board
GPIO12: MD1.45 (GPIO12); also elsewhere on the board
GPIO13: MD1.47 (GPIO13); also elsewhere on the board
GPIO14: MD1.51 (GPIO14); also elsewhere on the board
GPIO15: MD1.53 (GPIO15); also elsewhere on the board
GPIO16: MD1.57 (GPIO16); also elsewhere on the board
GPIO17: MD1.59 (GPIO17); also elsewhere on the board
GPIO18: MD1.63 (GPIO18); also elsewhere on the board
GPIO19: MD1.65 (GPIO19); also elsewhere on the board
GPIO20: MD1.69 (GPIO20); also elsewhere on the board
GPIO21: MD1.71 (GPIO21); also elsewhere on the board
GPIO22: MD1.75 (GPIO22); also elsewhere on the board
GPIO23: MD1.77 (GPIO23); also elsewhere on the board
GPIO24: MD1.81 (GPIO24); also elsewhere on the board
GPIO25: MD1.83 (GPIO25); also elsewhere on the board
GPIO26: MD1.87 (GPIO26); also elsewhere on the board
GPIO27: MD1.89 (GPIO27); also elsewhere on the board
GPIO40: MD1.70 (GPIO40); also elsewhere on the board
GPIO44: MD1.82 (GPIO44), R8.1
GPIO45: MD1.84 (GPIO45), R7.1; also elsewhere on the board
HDMI_CEC: MD1.171 (HDMI_CEC); also elsewhere on the board
HDMI_CLK_N: MD1.111 (HDMI_CLK_N); also elsewhere on the board
HDMI_CLK_P: MD1.113 (HDMI_CLK_P); also elsewhere on the board
HDMI_D0_N: MD1.117 (HDMI_D0_N); also elsewhere on the board
HDMI_D0_P: MD1.119 (HDMI_D0_P); also elsewhere on the board
HDMI_D1_N: MD1.123 (HDMI_D1_N); also elsewhere on the board
HDMI_D1_P: MD1.125 (HDMI_D1_P); also elsewhere on the board
HDMI_D2_N: MD1.129 (HDMI_D2_N); also elsewhere on the board
HDMI_D2_P: MD1.131 (HDMI_D2_P); also elsewhere on the board
HDMI_HPD_N_1V8: MD1.88 (HDMI_HPD_N_1V8); also elsewhere on the board
HDMI_SCL: MD1.175 (HDMI_SCL); also elsewhere on the board
HDMI_SDA: MD1.173 (HDMI_SDA); also elsewhere on the board
unnamed: D1.1 (K), Q1.3 (D)
unnamed: D1.2 (A), R2.2
unnamed: D8.2 (A), R11.2
USB_D_N: MD1.167 (USB_DM); also elsewhere on the board
USB_D_P: MD1.165 (USB_DP); also elsewhere on the board
USB_OTGID: MD1.168 (USB_OTGID), R3.1

Parts:
C9: 100nF; C_0402
C10, C11, C14, C15: 10uF; CP_Tantalum_Case-C_EIA-6032-28_Reflow
F1: 2A 6V; Polyfuse_0805
P1: POWER; USB_Micro-B
Q2: DMP3056L-7; SOT-23
U1: REG1117-3.3; SOT-223-3_TabPin2
U3: REG1117A-1.8; SOT-223-3_TabPin2

Connections:
+1V8: C15.1, U3.2 (VO); also elsewhere on the board
+3V3: C11.1, U1.2 (VO); also elsewhere on the board
+5V: C9.1, C10.1, C14.1, Q2.2 (S), U1.3 (VI), U3.3 (VI); also elsewhere on the board
GND: C9.2, C10.2, C11.2, C14.2, C15.2, P1.5 (GND), P1.6 (shield), Q2.1 (G), U1.1 (GND), U3.1 (GND); also elsewhere on the board
unnamed: F1.1, Q2.3 (D)
unnamed: F1.2, P1.1 (VBUS)

Parts:
C16: 10uF; CP_Tantalum_Case-C_EIA-6032-28_Reflow
C17: 100nF; C_0402
C20, C21: 10uF; C_0805
C22, C23: 33nF; C_0402
D2, D3: BAT54; SOT-23
D4, D5, D6, D7, D9, D10: BAV99; SOT-23
J1: 2001-1-2-21-00-BK; HDMI_MOLEX_471510001
J2: JC-128
P2: HOST; USB_A
P3: CAM1; FPC_22
P4: CONN_02X20; Pin_Header_Straight_2x20
P5: CAM0; FPC_22
Q3: 2N7002P.215; SOT-23
R4, R5: 1.8K; R_0603_HandSoldering
R6: 100K; R_0603_HandSoldering
R12, R13: 150R; R_0603_HandSoldering
R14, R15: 270R; R_0603_HandSoldering

Connections:
+3V3: D4.2 (K), D9.2 (K), D10.2 (K), P3.22, P4.1, P4.17, P5.22; also elsewhere on the board
+5V: D2.1 (A), D3.1 (A), P4.2, P4.4, R4.1, R5.1; also elsewhere on the board
CAM0_C_N: P5.8; also elsewhere on the board
CAM0_C_P: P5.9; also elsewhere on the board
CAM0_D0_N: P5.2; also elsewhere on the board
CAM0_D0_P: P5.3; also elsewhere on the board
CAM0_D1_N: P5.5; also elsewhere on the board
CAM0_D1_P: P5.6; also elsewhere on the board
CAM0_IO0: P5.17; also elsewhere on the board
CAM0_IO1: P5.18; also elsewhere on the board
CAM1_C_N: P3.8; also elsewhere on the board
CAM1_C_P: P3.9; also elsewhere on the board
CAM1_D0_N: P3.2; also elsewhere on the board
CAM1_D0_P: P3.3; also elsewhere on the board
CAM1_D1_N: P3.5; also elsewhere on the board
CAM1_D1_P: P3.6; also elsewhere on the board
CAM1_D2_N: P3.11; also elsewhere on the board
CAM1_D2_P: P3.12; also elsewhere on the board
CAM1_D3_N: P3.14; also elsewhere on the board
CAM1_D3_P: P3.15; also elsewhere on the board
CAM1_IO0: P3.17; also elsewhere on the board
CAM1_IO1: P3.18; also elsewhere on the board
CD0_SCL: P5.20; also elsewhere on the board
CD0_SDA: P5.21; also elsewhere on the board
CD1_SCL: P3.20, P4.5; also elsewhere on the board
CD1_SDA: P3.21, P4.3; also elsewhere on the board
GND: C16.2, C17.2, C22.2, C23.2, D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), D9.1 (A), D10.1 (A), J1.2, J1.5, J1.8, J1.11, J1.17, J1.SH, J2.1 (S), P2.4, P2.5, P3.1, P3.4, P3.7, P3.10, P3.13, P3.16, P3.19, P4.6, P4.9, P4.14, P4.20, P4.25, P4.27, P4.28, P4.30, P4.34, P4.39, P5.1, P5.4, P5.7, P5.10, P5.11, P5.12, P5.13, P5.14, P5.15, P5.16, P5.19, Q3.2 (S), R12.2, R13.2; also elsewhere on the board
GPIO4: P4.7; also elsewhere on the board
GPIO5: P4.29; also elsewhere on the board
GPIO6: P4.31; also elsewhere on the board
GPIO7: P4.26; also elsewhere on the board
GPIO8: P4.24; also elsewhere on the board
GPIO9: P4.21; also elsewhere on the board
GPIO10: P4.19; also elsewhere on the board
GPIO11: P4.23; also elsewhere on the board
GPIO12: P4.32; also elsewhere on the board
GPIO13: P4.33; also elsewhere on the board
GPIO14: P4.8; also elsewhere on the board
GPIO15: P4.10; also elsewhere on the board
GPIO16: P4.36; also elsewhere on the board
GPIO17: P4.11; also elsewhere on the board
GPIO18: P4.12; also elsewhere on the board
GPIO19: P4.35; also elsewhere on the board
GPIO20: P4.38; also elsewhere on the board
GPIO21: P4.40; also elsewhere on the board
GPIO22: P4.15; also elsewhere on the board
GPIO23: P4.16; also elsewhere on the board
GPIO24: P4.18; also elsewhere on the board
GPIO25: P4.22; also elsewhere on the board
GPIO26: P4.37; also elsewhere on the board
GPIO27: P4.13; also elsewhere on the board
GPIO40: R15.1; also elsewhere on the board
GPIO45: R14.1; also elsewhere on the board
HDMI_CEC: D4.3 (common), J1.13; also elsewhere on the board
HDMI_CLK_N: J1.12; also elsewhere on the board
HDMI_CLK_P: J1.10; also elsewhere on the board
HDMI_D0_N: J1.9; also elsewhere on the board
HDMI_D0_P: J1.7; also elsewhere on the board
HDMI_D1_N: J1.6; also elsewhere on the board
HDMI_D1_P: J1.4; also elsewhere on the board
HDMI_D2_N: J1.3; also elsewhere on the board
HDMI_D2_P: J1.1; also elsewhere on the board
HDMI_HPD_N_1V8: R6.1; also elsewhere on the board
HDMI_SCL: D5.3 (common), J1.15, R4.2; also elsewhere on the board
HDMI_SDA: D6.3 (common), J1.16, R5.2; also elsewhere on the board
unnamed: C16.1, D2.3 (K), P2.1
unnamed: C17.1, D3.3 (K), D5.2 (K), D6.2 (K), D7.2 (K), J1.18
unnamed: C20.1, C23.1, R13.1, R14.2
unnamed: C20.2, D10.3 (common), J2.2 (T)
unnamed: C21.1, C22.1, R12.1, R15.2
unnamed: C21.2, D9.3 (common), J2.5 (R)
unnamed: D7.3 (common), J1.19, Q3.1 (G)
unnamed: Q3.3 (D), R6.2
USB_D_N: P2.2; also elsewhere on the board
USB_D_P: P2.3; also elsewhere on the board

Board: 4 copper layers, 93.2 x 62.4 mm, 64 parts (26 on the bottom side), 84 nets.

## Commit log

2018-12-13 Assigned footprints to most components
2018-12-13 Added HDMI footprints
2018-12-14 Added camera connector footprint
2018-12-16 Laid down components
2018-12-16 Replaced HDMI connector
2018-12-16 Moved more components to the top
2018-12-17 Fixed fused
2018-12-17 Routed differential pairs for camera and HDMI
2018-12-17 Routed the rest of the board
2018-12-17 Stitched ground planes with vias
2018-12-17 More via stitching
2018-12-18 Regenerated BOM
2018-12-18 Removed 2.5V regulator and changed bottom ground plane clearence
2018-12-18 Added decoupling caps for gpio power pins
2018-12-18 Added pull-ups for gpio28, 29, 44 and 45
2018-12-18 Moved CAM1_IO0 and CAM1_IO1 to gpio 31 and 30
2018-12-18 Partially routed gpio header
2018-12-19 Routed gpio header
2018-12-20 Changed ground via size
2018-12-20 Added labels on silkscreen
2018-12-21 Minor fixes and rounded board edges
2018-12-21 Moved camera sda and scl to gpio 28 and 29
2018-12-21 Added power LED
2018-12-22 Minor fixes
2018-12-22 Added audio jack
2018-12-22 Removed unnecessary libs
2018-12-22 Cleaned up libs
2018-12-22 Replaced 1uF input cap with 100nF
2018-12-23 Added license
2018-12-23 Added license info for sodimm connector
2018-12-23 Added license info for hdmi schematic symbol
2018-12-23 Generated gerber files
2018-12-23 Added nc to unused audio jack pins
2019-01-27 Added datasheet links to BOM
2019-01-27 Added board photo
2019-01-27 Added schematic PDF
2019-01-27 Added device tree file
2021-02-08 Schematic changes to support CAM0
2021-02-16 Device tree changes to support CAM0
    Based on official instructions from https://www.raspberrypi.org/documentation/hardware/computemodule/cmio-camera.md
2021-03-22 Initial PCB changes to support CAM0+CAM1
2021-03-22 Unhide F.SilkS
2021-03-23 Improve P5 GND connections
2021-03-23 Better align the CAM0 lines
2021-03-23 Rev the board code
2021-03-23 Adjust R16 label position
2021-03-24 Redo CAM0 differential pairs
2021-03-25 Shorten CAM0 tracks in preparation for tuning
2021-03-25 Tune CAM0 signal pairs intra-pair
2021-03-25 Tune CAM0 signal pairs inter-pair
2021-03-25 Redo and retune CAM0 differential pairs
2021-03-27 Redo P5 GND. Add more stitching vias
2021-03-28 Clean up PCB. Fixes #3
2021-03-29 Rev board code (cont'd)
